# Install packages in an image
IMAGE_INSTALL += " \
    example-copy-file \
    example-c-cc \
    example-c-makefile \
    example-c-cmake \
    "
