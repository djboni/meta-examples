# Install packages in an image
IMAGE_INSTALL += " \
    qt6-simple-calculator \
    "
